# Keil uVision project rtos.uvprojx, settings and files
target stm32f401re (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtos
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F401xE
  c include: .\rtKernel
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group app
    ./Application/: main.c
  group driver
    ./Driver/: startup_stm32f401xe.s system_stm32f4xx.c
  group rtKernel
    ./rtKernel/: rtKernel.c rtKernel.h rtKernel.s
software components: CMSIS:CORE 4.3.0
